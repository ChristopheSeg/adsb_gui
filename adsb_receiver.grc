options:
  parameters:
    category: Custom
    comment: |-
      ------------------ATTENTION 
      Si le bloc File Sink est active, le nombre de fichiers enregistres 
      peut devenir prohibitif et remplir votre disque! Vous devez 
      absolument traiter ces donnees avec un script ad'hoc qui 
      les supprimera apres traitement.
    generate_options: qt_gui
    id: adsb_receiver
    output_language: python
    title: Recepteur ADSB -Mode-S
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    orient: Qt.Horizontal
    start: '950000000'
    step: '10000'
    stop: '1093000000'
    value: '1090000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: seuil
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Seuil
    orient: Qt.Horizontal
    start: '0.0001'
    step: '0.0001'
    stop: '0.3'
    value: '0.003'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '80'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: short
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '128'
    type: byte
  states: {state: disabled}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: ''
    true_value: 'True'
    type: byte
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    comment: |-
      chemin relatif ou absolu
      seuil recommande : 0.20
      valeurs entieres a convertir en complexes
    file: adsb_2000kSps2_1uint8_10Msamples.bin
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    comment: |-
      chemin relatif ou absolu
      seuil recommande 0.2
    file: adsb_2M.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters: {}
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/128
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    comment: |-
      Les fichiers generes sont stockes dans le 
      repertoire du fichier adsb_decoder
    samp_rate: samp_rate
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: seuil
    init: '0'
    low: seuil
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '010100001010000001001010110'
    comment: '010100001010000001001010110'
    tagname: burst
    threshold: '0'
    type: byte
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    comment: Make path relative
    source_code: |
      # https://stackoverflow.com/questions/46285550/relative-path-to-files-in-gnu-radio-companion
      #
      # this module will be imported in the into your flowgraph
      # GNU Radio Companion (GRC) paths are relative to where GRC is started.
      #
      # If the script is intended to be run from its containing directory, a "Python Module" block can be added to GRC with the contents:

      import os

      script_path = os.path.dirname(os.path.realpath(__file__))
      os.chdir(script_path)
  states: {}
- name: figures
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,3,2
    label0: Waterfall (recu)
    label1: Spectre (recu)
    label2: 'Rx: temporel / bits'
    num_tabs: '3'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '70'
    gain_dB_ch1: '30'
    oversample: '0'
    rf_freq: freq
    samp_rate: samp_rate
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: figures@1
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: figures@2:0,0,1,1
    label1: ''
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: float
    ylabel: Rx mag2
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: figures@2:0,1,1,1
    label1: ''
    marker1: '8'
    size: '250'
    srate: samp_rate
    tr_delay: '0.000008'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
    ylabel: Manchester bits
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 'figures@0:'
    name: '"Spectre"'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    bw0: samp_rate
    dc_offset_mode0: '2'
    freq0: freq
    gain0: '14'
    gain_mode0: 'True'
    if_gain0: '24'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bits_stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bits_stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: rx
  states: {}

connections:
- [analog_sig_source_x_1, '0', blocks_burst_tagger_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_burst_tagger_0, '0', blocks_null_sink_0, '0']
- [blocks_burst_tagger_0, '0', blocks_tagged_file_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_file_source_0_1, '0', blocks_throttle_0, '0']
- [blocks_float_to_uchar_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_throttle_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_uchar_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_2, '0']
- [digital_correlate_access_code_tag_xx_0, '0', virtual_sink_0, '0']
- [limesdr_source_0, '0', virtual_sink_1, '0']
- [rtlsdr_source_0_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_burst_tagger_0, '0']
- [virtual_source_0, '0', blocks_uchar_to_float_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_1_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
